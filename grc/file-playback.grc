<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>udp_higgs_rx_63</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>channel_select</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>63</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>63</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>fine_cfo</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>-2</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(31.25E6 * (64.0/1024))</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>variable_slider_0</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>200</value></param>
<param><key>min</key><value>-200</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/x/Desktop/outputc.raw</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/mnt/overflow/work/software_parent_repo/higgs_sdr_rev2/libs/s-modem/soapy/js/test/data/single_sc_1.raw</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>64</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>int(channel_select)</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>64</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>63</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>64</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>62</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>64</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>int(channel_select)+2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>1.0/((2**15) - 1 )</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_2_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>samples_per_second</key><value>samp_rate/64</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_udp_source</key>
<param><key>id</key><value>blocks_udp_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>type</key><value>short</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>port</key><value>10006</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>grid_pos</key><value>0,0,1,1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>31.25E6 / 1024</value></param>
<param><key>t_scale</key><value>0.1</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.1</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_2</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>31.25E6 / 1024</value></param>
<param><key>t_scale</key><value>0.1</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.1</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_3</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>31.25E6 / 1024</value></param>
<param><key>t_scale</key><value>0.1</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.1</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_3_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>31.25E6 / 1024</value></param>
<param><key>t_scale</key><value>0.1</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>.1</value></param>
<param><key>xy_mode</key><value>True</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>blocks_multiply_xx_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>wxgui_scopesink2_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0</source_block_id><sink_block_id>blocks_null_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_1_0_0</source_block_id><sink_block_id>blocks_null_sink_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_udp_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
